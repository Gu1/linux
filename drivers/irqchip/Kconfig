## drivers/irqchip/Kconfig
```kconfig
config ARM64_GIC
	depends on ARM64
	bool
	help
	  ARM Generic Interrupt Controller support. Only used on arm64 plaftorms at present.
```
